inherit core-image

IMAGE_INSTALL += " \
    curl \
    vim \
    systemd-analyze \
    "
